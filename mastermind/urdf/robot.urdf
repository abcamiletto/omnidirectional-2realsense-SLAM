Commit message: fine tuning with cover on

File: mastermind/urdf/robot.urdf (robot description, URDF)
Before this commit: robot platform, 1 links, 0 joints
Links:
- link base_link: geometry visual mesh filename=package://mastermind/urdf/meshes/robot2.stl scale=0.001 0.001 0.001
